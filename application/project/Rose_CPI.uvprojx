# Keil uVision project Rose_CPI.uvprojx, settings and files
target Rose_CPI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Rose_CPI
  c flags: oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\library\\hallib\STM32F4xx_HAL_Driver\Inc;..\module\delay;..\module\sys;..\module\usart;..\module\led;..\module\key;..\module\can;..\usr;..\kernel;..\kernel\ports;..\usr\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group usr
    ../module/sys/: init.c
    ../usr/src/: main.c superTask.c ManageChargerTask.c CpiFSMTask.c HmiTask.c DebugConsoleCommTask.c EthernetTask.c FileTask.c LogTask.c SDDiskTask.c USBTask.c
  group kernel
    ../kernel/sources/: OS_CORE.c OS_EVENT.C OS_SHELL.c OS_TIMER.c
    ../kernel/ports/: os_cpu_c.c os_cpu_a.s
  group libray
    ../library/CORE/: core_cm4.h
    ../library//CORE/: cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../library//HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
    ../library/hallib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_eth.c stm32f4xx_hal_crc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c
  group startup
    ../usr/: stm32f4xx_it.c system_stm32f4xx.c
    ../library//CORE/: startup_stm32f429xx.s
  group module
    ../module/delay/: delay.c
    ../module/usart/: usart.c
    ../module/LED/: led.c
    ../module/KEY/: key.c
    ../module/can/: can.c can_to_spi_MCP2515.c
